# IAR project Sensor.ewp, settings and files
configuration Sensor (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ..\..\code\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sensor.bin
  ILINK.IlinkOutputFile: Sensor.out
  ILINK.IlinkIcfFile: stm32l152xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/code
    ../../code/rtc/: apprtc.c
    ../../code/common/: common.c
    ../../code/sensorapp/: sensorapp.c
    ../../code/Uart/: uartapp.c
  group Application/code/inc
    ../../code/inc/: apprtc.h common.h deveice.h devproanaly.h devprotocol.h include.h lcddriver.h sensorapp.h uartapp.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xc.s startup_stm32l152xc.s
  group Application/User
    ../Src/: gpio.c i2c.c main.c rtc.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c usart.c stm32l1xx_hal_msp.c adc.c gpio.c rtc.c main.c i2c.c stm32l1xx_it.c tim.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc.c stm32l1xx_hal.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_i2c.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim_ex.c
